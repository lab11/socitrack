# Repository lab11/socitrack (continued)

## EAGLE design hardware/tottag/rev_n/rev_n v67.brd (continued)

Schematic: rev_n v31.sch, sheet 3, Localization module

Parts:
A1, A2, A3: ACR0301U
C2: 2pF; 0201_CAP; MPN CBR02C209A5GAC
C3, C4: 3.3pF; SMD_2012M-0805US-C; MPN 600F3R3BT250XT
C11: 0.1uF; SMD_3216M-1206US-C; MPN GRM31C5C1H104JA01L
C12, C13, C14: 4.7nF; SMD_1608M-0603US-C; MPN C0603C472J5GAC7867
C22, C24: 0.1uF; SMD_1608M-0603US-C; MPN C1608X7R1H104K080AA
C23, C25, C26, C33, C34: 0.1uF; 0402_CAP; MPN CL05A104KP5NNNC
C37: 0.22uF; SMD_1608M-0603US-C; MPN C1608X7R1H224K080AB
C43: 100pF; SMD_1005M-0402US-C; MPN C0402C101J3GACTU
C49, C50: 4.7uF; 0603_CAP; MPN C1608X7S1A475K080AC
C54, C55: 10uF; SMD_1608M-0603US-C; MPN CM105X5R106M25AT
C90, C91: 1uF; 0201_CAP; MPN GRM033R61A105ME44D
CX1, CX2: DNP; 0603_CAP
FB1: BLM03PG330SN1D; 0201_FB; MPN BLM03PG330SN1D
JP3, JP12: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
R1: 49.9-1%; 0201_RES; MPN ERJ-1GNF49R9C
R24: 100k; 0402_RES; MPN RT0402BRE07100KL
RX1: DNP; 0603-RES
RZ1, RZ2: 0; 0603-RES; MPN RMCF0603ZT0R00
RZ4: 0; 0402_RES; MPN RMCF0402ZT0R00
S2: SKY13373
S3: SIP3241XSIP32414; TDFN2X2X0P6-8
S4: MM8030-2610
TP0, TP1, TP2, TP3, TP4, TP5, TP6, TP7: TEST-POINT; PAD.03X.03
U2: DW3110; WLCSP52
U7: QM14068
VR3: TPS7A0218PDQNR; 4-XDFN-EP
X4: TXC-8Y; MPN 8Y38472012

Connections:
+2V5: C34.1, C49.1, C90.P$1 (1), RX1.1, S2.6 (VDD), S3.1 (IN), VR3.4 (IN); also elsewhere on the board
ANT1: A1.FEED, U7.2 (LNA_IN)
AP4_GP14/TT_!DW_SPI_CS: U2.B5 (!SPICS); also elsewhere on the board
AP4_GP24/TT_RFSW_V1: CX2.1, S2.4 (V1); also elsewhere on the board
AP4_GP25/TT_RFSW_V2: CX1.1, S2.5 (V2); also elsewhere on the board
AP4_GP26/TT_DW_WAKEUP: U2.B9 (WAKEUP); also elsewhere on the board
AP4_GP27/TT_DW_IRQ: R24.2, U2.B1 (IRQ/GPIO8); also elsewhere on the board
AP4_GP31/TT_DW_SPI_CLK: U2.A8 (SPICLK); also elsewhere on the board
AP4_GP32/TT_DW_SPI_IO0: U2.B7 (SPICDI(MOSI)); also elsewhere on the board
AP4_GP33/TT_DW_SPI_IO1: U2.A6 (SPICDO(MISO)); also elsewhere on the board
AP4_GP50/TT_!DW_RESET: U2.A10 (!RST); also elsewhere on the board
DW_EXTON: JP12.2, RX1.2, S3.2 (CTL), S3.3 (CTL), VR3.3 (EN); also elsewhere on the board
DW_EXTON_RAW: JP12.3, U2.A12 (EXTON); also elsewhere on the board
DW_GPIO4: TP4.P$1, U2.F1 (GPIO4/EXTPA)
DW_GPIO5: TP5.P$1, U2.D1 (GPIO5/EXTTXE/SPIPOL)
DW_GPIO6/EXTRXE: JP3.3, TP6.P$1, U2.C4 (GPIO6/EXTRXE/SPIPHA); also elsewhere on the board
DW_RF1: C2.P$1 (1), U2.H11 (RF1)
DW_RF2: R1.1, U2.H5 (RF2)
DW_RXLED: TP2.P$1, U2.E4 (GPIO2/RXLED)
DW_RXOKLED: TP0.P$1, U2.C2 (GPIO0/RXOKLED)
DW_SFDLED: TP1.P$1, U2.D3 (GPIO1/SFDLED)
DW_SYNC: TP7.P$1, U2.G2 (GPIO7/SYNC)
DW_TXLED: TP3.P$1, U2.E2 (GPIO3/TXLED)
DW_VDD2A: C12.P$1, FB1.P$2, U2.F15 (VDD2A)
DW_VDD2_PWROUT: C33.1, RZ1.1, S3.8 (OUT)
DW_VDD2_SUP: C13.P$1, C24.P$1, C55.P$1, FB1.P$1, RZ1.2, U2.B15 (VDD2B)
DW_VDD3_PWROUT: C25.1, RZ2.1, S3.5 (OUT)
DW_VDD3_SUP: C14.P$2, C22.P$2, C54.P$2, RZ2.2, U2.D15 (VDD3)
DW_VIO_D: C23.1, U2.A4 (VIO_D)
DW_VTX_D: C37.P$2, U2.C14 (VTX_D)
DW_XT0: C4.P$1, U2.G14 (XTO), X4.3 (2)
DW_XTI: C3.P$1, U2.H15 (XTI), X4.1
GND: C3.P$2, C4.P$2, C11.P$2, C12.P$2, C13.P$2, C14.P$1, C22.P$1, C23.2, C24.P$2, C25.2, C26.2, C33.2, C34.2, C37.P$1, C43.P$2, C49.2, C50.1, C54.P$1, C55.P$2, C90.P$2 (2), C91.P$2 (2), CX1.2, CX2.2, JP3.1, R1.2, R24.1, S2.2 (GND), S2.7 (GND), S2.8 (GND), S2.10 (GND), S2.12 (GND), S2.PAD (GND), S3.6 (GND), S3.7 (GND), S3.PAD (GND), S4.G1 (GND), S4.G2 (GND), U2.A2 (VSS), U2.A14 (VSS1), U2.B3 (VSS), U2.B11 (VSS1), U2.C6 (VSS), U2.C8 (VSS1), U2.C10 (VSS1), U2.C12 (VSS3), U2.D5 (VSS), U2.D7 (VSS), U2.D9 (VSS1), U2.D11 (VSS2), U2.D13 (VSS3), U2.E6 (GND-RF), U2.E10 (GND-RF), U2.E12 (GND-RF), U2.E14 (VSS2), U2.F7 (GND-RF), U2.F9 (GND-RF), U2.G6 (GND-RF), U2.G10 (GND-RF), U2.H1 (GND-RF), U2.H3 (GND-RF), U2.H7 (GND-RF), U2.H9 (GND-RF), U2.H13 (GND-RF), U7.3 (GND), U7.4 (GND), U7.5 (GND), U7.7 (GND), U7.9 (GND), VR3.2 (GND), VR3.PAD (GND), X4.2 (GND), X4.4 (GND); also elsewhere on the board
LNA_VCTRL: JP3.2, U7.8 (VCTRL); also elsewhere on the board
RF1: S2.9 (J2), U7.6 (LNA_OUT)
RF2: A2.FEED, S2.3 (J3)
RF3: A3.FEED, S2.1 (J1), S4.IN, S4.OUT (A)
RFC: C2.P$2 (2), S2.11 (RFC)
VDD_LNA: C11.P$1, C43.P$1, RZ4.2, U7.1 (VDD)
VR3_OUT: C91.P$1 (1), RZ4.1, VR3.1 (OUT)

Notes on the sheet:
Supply 2.4 - 3.6 V ds #'s @ 3.0 V min typ max VDD1 1.6 3.0 3.6 VDD2a,b 2.4 3.0 3.6 VDD3 1.5 3.0 3.6 Voltage on GPIO0-5, WAKEUP, RSTn, SPICSn, SPIMOSI, SPICLK -> Max: VDD1+0.3V I/O current (max): 10 mA VDD1 -> I/O Peak cont current is RX CH9: 88 mA TX worst-case: VDD2a/b: 20 mA VDD3: 20 mA RX worst-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
SupV 2.5-4.8 I/O V 1.65-min(3.3,SupV) Active: 60 µA Qui: 5 µA
V1 V2 State 0 0 Shutdown 1 0 RFC<>J2 0 1 RFC<>J1 1 1 RFC<>J3
Datasheet says no passives are needed However, EVB sch has 100 pF filters. Add hedge for option
Hedge: Allow disabling of low-power mode

Schematic: rev_n v31.sch, sheet 4, External signals

Parts:
FD1, FD2, FD4, FD6: FIDUCIAL; FIDUCIAL_1MM-CU_2MM-MASK

Notes on the sheet:
Miscellany
Fiducials - Top
Fiducials - Bottom

Schematic: rev_n v31.sch, sheet 5, Apollo4 IC

Parts:
A4: AMCA72-2R47G-S1F-T; AMCA72-2R470G-S1F-T
C1: 1.5pF; CAPC1005X60; TOLERANCE +/- 0.25pF; MPN C0402C159C5GACTU
C58, C59, C60, C61, C66, C67, C70, C71, C72, C73, C74, C75: 2.2uF; 0201_CAP; MPN GRM033R61A225KE47D
C62, C63, C64, C65, C79, C93: 1uF; 0201_CAP; MPN GRM033R61A105ME44D
C69: 4.7uF; 0402_CAP; MPN CL05A475MP5NRNC
C76: 4700pF; CAPC1005X60; MPN KGM05AR71E472KH
C80, C81: 6pF; CAPC1005X60; MPN GCM1555C1H6R0BA16D
CX3, CX4, CX5: DNP; CAPC1005X60
D3: ZENER; SODFL1608X70; MPN PESD5V0X1UB,135
L5: 2.2µH; 0805_CAP; MPN DFE201210U-2R2M=P2
L6: 1.0µH; 0603_CAP; MPN DFE18SAN1R0ME0L
L7: 2.0nH; INDC1006X60N; TOLERANCE +/- 0.1 nH; MPN LQG15HS2N0B02D
L8: 2.2nH; INDC1006X60N; TOLERANCE +/- 0.1 nH; MPN LQG15HN2N2B02D
RZ9: 0; 0402_RES; MPN RMCF0402ZT0R00
TP8: VDDBH; PAD.03X.03
TP9: VDDP; PAD.03X.03
TP10: VDDF; PAD.03X.03
U1: APOLLO4_BLUE_PLUS_SOC_KBR; APOLLO4_BLUE_SOC_BGA
X1: ABM12W; MPN ABM12W-32.0000MHZ-6-D1X-T3
X3: TXC-9HT12; MPN 9HT12-32.768KDZY-T

Connections:
AGND: C1.2, C93.P$2 (2), CX5.2, U1.M1 (RFIOM), U1.M3 (RFSUB-RF_SUBSTRATE_GND)
AP4_!RESET: C76.1, D3.1 (C), U1.A6 (!RST); also elsewhere on the board
AP4_GP06/TT_FLASH_!HOLD_IO3: U1.J5 (GPIO6); also elsewhere on the board
AP4_GP08/TT_9DOF_H_SCL/SCK/RX: U1.H2 (GPIO31); also elsewhere on the board
AP4_GP13/TT_9DOF_!BOOT: U1.D5 (GPIO13); also elsewhere on the board
AP4_GP14/TT_!DW_SPI_CS: U1.D6 (GPIO14); also elsewhere on the board
AP4_GP17/TT_9DOF_H_!INT: U1.D4 (GPIO17); also elsewhere on the board
AP4_GP18/TT_BATIN: U1.D3 (GPIO18); also elsewhere on the board
AP4_GP24/TT_RFSW_V1: U1.E2 (GPIO24); also elsewhere on the board
AP4_GP25/TT_RFSW_V2: U1.K5 (GPIO25); also elsewhere on the board
AP4_GP26/TT_DW_WAKEUP: U1.L5 (GPIO26); also elsewhere on the board
AP4_GP27/TT_DW_IRQ: U1.M5 (GPIO27); also elsewhere on the board
AP4_GP30/TT_FLASH_!WP: U1.G4 (GPIO30); also elsewhere on the board
AP4_GP31/TT_DW_SPI_CLK: U1.E8 (GPIO8); also elsewhere on the board
AP4_GP32/TT_DW_SPI_IO0: U1.E7 (GPIO9); also elsewhere on the board
AP4_GP33/TT_DW_SPI_IO1: U1.E6 (GPIO10); also elsewhere on the board
AP4_GP47/TT_FLASH_SCK: U1.F1 (GPIO47); also elsewhere on the board
AP4_GP48/TT_FLASH_PDI_IO0: U1.E1 (GPIO48); also elsewhere on the board
AP4_GP49/TT_FLASH_PDO_IO1: U1.D1 (GPIO49); also elsewhere on the board
AP4_GP50/TT_!DW_RESET: U1.A9 (GPIO50); also elsewhere on the board
AP4_GP51/LED1_GREEN: U1.B9 (GPIO51); also elsewhere on the board
AP4_GP53/LED1_RED: U1.C9 (GPIO53); also elsewhere on the board
AP4_GP55/TT_BUZZER_GATE: U1.D9 (GPIO55); also elsewhere on the board
AP4_GP58/TT_!CHG: U1.J7 (GPIO58); also elsewhere on the board
AP4_GP60/TT_!PG: U1.K8 (GPIO60); also elsewhere on the board
AP4_GP63/TT_9DOF_PS0/WAKE: U1.M6 (GPIO63); also elsewhere on the board
AP4_GP65/TT_9DOF_!RESET: U1.A7 (GPIO65); also elsewhere on the board
AP4_GP66/TT_QI_TS_CTRL: U1.A8 (GPIO66); also elsewhere on the board
AP4_GP69/TT_FLASH_!CS: U1.B8 (GPIO69); also elsewhere on the board
AP4_GP72/TT_9DOF_H_!CS: U1.C8 (GPIO72); also elsewhere on the board
AP4_GP79/LED2_RED: U1.M11 (GPIO79); also elsewhere on the board
AP4_GP88/LED2_YLW: U1.F9 (GPIO88); also elsewhere on the board
AP4_LPADC_VREF: C79.P$2 (2), U1.A12 (LPADC_VREF)
AP4_LPMICBIAS: C71.P$2 (2), U1.B10 (LPMICBIAS)
AP4_RFIOP1: CX5.1, L7.1, U1.M2 (RFIOP)
AP4_SWDCLK: U1.K3 (GPIO20); also elsewhere on the board
AP4_SWDIO: U1.J3 (GPIO21); also elsewhere on the board
AP4_SWO: U1.L4 (GPIO3); also elsewhere on the board
AP4_USB0_N: U1.M8 (USB0PN)
AP4_USB0_P: U1.M7 (USB0PP)
AP4_VDDBH: C69.1, L6.2, RZ9.1, TP8.P$1, U1.G12 (VDDBH--BLE_BUCK_VOUT)
AP4_VDDBH_RF: C93.P$1 (1), RZ9.2, U1.J1 (VDDBH_RF--BLE_BUCK_RF_VOUT)
AP4_VDDBH_SW: L6.1, U1.H12 (VDDBH_SW--BLE_BUCK_SW)
AP4_VDDC: C59.P$1 (1), U1.A3 (VDDC-CORE)
AP4_VDDC_LV: C60.P$1 (1), U1.B3 (VDDC_LV-CORE_LV)
AP4_VDDF: C61.P$1 (1), C75.P$1 (1), TP10.P$1, U1.C2 (VDDF-MEM)
AP4_VDDMIPI_1P8: C70.P$1 (1), U1.H10 (VDD18-MIPI); also elsewhere on the board
AP4_VDDS: C58.P$1 (1), U1.C1 (VDDS-SRAM_HV_SUP)
AP4_VDDUSB_0P9: C73.P$1 (1), U1.L7 (VDDUSB0P9); also elsewhere on the board
AP4_VDDUSB_3P3: C74.P$1 (1), U1.K7 (VDDUSB33); also elsewhere on the board
AP4_XI: C81.1, U1.A4 (XI), X3.2
AP4_XI32M: CX4.1, U1.C12 (XI32M), X1.3 (2)
AP4_XO: C80.1, U1.A5 (XO), X3.1
AP4_XO32M: CX3.1, U1.D12 (XO32M), X1.1
BLE_RFOUT: A4.S1, L8.2
GND: C58.P$2 (2), C59.P$2 (2), C60.P$2 (2), C61.P$2 (2), C62.P$2 (2), C63.P$2 (2), C64.P$2 (2), C65.P$2 (2), C66.P$2 (2), C67.P$2 (2), C69.2, C70.P$2 (2), C71.P$1 (1), C72.P$2 (2), C73.P$2 (2), C74.P$2 (2), C76.2, C79.P$1 (1), C80.2, C81.2, CX3.2, CX4.2, D3.2 (A), U1.B2 (VSSP-BUCK_REGS_GND), U1.B5 (VSSA-ANALOG_GND), U1.B12 (VSSAUDA), U1.D2 (VSS-DGND_FOR_VDDF_AND_PADS), U1.E12 (VSSAUDD), U1.H1 (VSSB-BLE_UNREG_GND), U1.J10 (VSS18-MIPI), U1.L1 (VSSVCO-BLECORE_GND_FOR_VCO), U1.L2 (VSSS-HVSIMOBUCK_GND), U1.L8 (VSSAUSB), X1.2 (GND), X1.4 (GND); also elsewhere on the board
unnamed: C1.1, L7.2, L8.1
SIMOBUCK_SW: L5.P$1 (1), U1.A1 (SIMOBUCK_SW)
SIMOBUCK_SWSEL: L5.P$2 (2), U1.A2 (SIMOBUCK_SWSEL)
VDDAUDA_1P8-CLEAN: C72.P$1 (1), U1.B11 (VDDAUDA); also elsewhere on the board

Notes on the sheet:
Supply 1.8-2.0 V M4 max sust: 4 mA Buck spikes: 100 mA BLE max sus: 6 mA (+1.2?) BLE buck spk: 2.2 mA
Note: Load caps DNP on Ambiq reference assembly
Int PUs, safe float
If Unused: Float data; gnd usb pwr
If Unused (no display): Float clk,data; gnd pwr
Unused (no mic yet..) Float inputs and bias out VRef always gen'd internally and expects 100nF cap
No idea what this does :( Datasheet doesn't explain anywhere. Reference board just pins out to general header
I/O Planning Notes
3 MSPI instances - MSPI0 seems normal, use → GPIO64-73 (PadFn0) - MSPI1-2 have many caveats, avoid
7 IOM (I2C/SPI), two power domains - IOM0-3 HCPB - IOM5-7 HCPC IOMn_SUBMODCTRL_SMODnEN reg disables submodule
MSPI0
IOM0
IOM1
Timers (PWM/buzzer) any GPIO pin (Pad Fn6)
KBR Package
For the KBR package of the Apollo4 Blue Plus SoC, the pins available for chip enables for the MSPI instances are limited to: GPIO14, 52, 56, 57, 60, 73, 75, 83, 84, 85, 86 and 91.
§30.2.4-6 Recommended Buck,Bypass,Ext Components
SWD Pins (req)
VREF generated internally, ext cap is filter
IOM3
AP4 datasheet— XI/XO int C: 3.4pF max ext C: 7 pF
AP4 datasheet— XI/XO int C: 3.4pF C-load: 6 pF (max) ESR: 100 Ω
Pad Fn4
Pad Fn2
Pad Fn0
Note: Load caps DNP after first-gen fab testing. EVB Populates with 6pF
Route USB0PN and USB0PP as 90Ω differential pair
Route CLKN, CLKP as 100Ω diff pair and 50Ω single-ended trcs
Route D0N and D0P as 100Ω diff pair and 50Ω signle-ended trcs
NOTE: EVB and ref sch have a 0.1uF here. As this is unused, replaced with 1uF to reduce BOM count.
IOM2
IOM5
IOM6
IOM7

Schematic: rev_n v31.sch, sheet 6, AP4 Support Circuits

Parts:
C77, C78: 1uF; 0201_CAP; MPN GRM033R61A105ME44D
D1: BICOLOR-SMD; LED-0606; MPN MCL0606FRD1GR1T
D2: BICOLOR-SMD; LED-0606; MPN MCL0606FYW1RD1T
J1, J2: TC2030-JLINK-NL-2SIDE; TC2030-IDC-NL-2SIDE
JP1: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
R2, R3: 5.1; 0402_RES; MPN RC0402JR-075R1L
R4, R5: 15; 0402_RES; MPN RC0402JR-0715RL
RZ6, RZ7, RZ8, RZ10, RZ11: 0; 0402_RES; MPN RMCF0402ZT0R00
VR2: TPS7A0218PDQNR; 4-XDFN-EP

Connections:
+2V5: C77.P$1 (1), RZ10.1, VR2.4 (IN); also elsewhere on the board
AP4_!RESET: J1.3 (!RESET), J1.B3 (!RESET); also elsewhere on the board
AP4_GP51/LED1_GREEN: R2.2; also elsewhere on the board
AP4_GP53/LED1_RED: R5.2; also elsewhere on the board
AP4_GP79/LED2_RED: R4.2; also elsewhere on the board
AP4_GP88/LED2_YLW: R3.2; also elsewhere on the board
AP4_LED2_BLUE_COMM: D1.C1, R5.1
AP4_LED_BLUE_COMM: D2.C2, R3.1
AP4_LED_GREEN_COMM: D2.C1, R4.1
AP4_LED_RED_COMM: D1.C2, R2.1
AP4_SWDCLK: J1.4 (SWDCLK), J1.B4 (SWDCLK); also elsewhere on the board
AP4_SWDIO: J1.2 (SWDIO), J1.B2 (SWDIO); also elsewhere on the board
AP4_SWO: J1.6 (SWO), J1.B6 (SWO); also elsewhere on the board
AP4_VDDMIPI_1P8: RZ8.1; also elsewhere on the board
AP4_VDDUSB_0P9: RZ6.1; also elsewhere on the board
AP4_VDDUSB_3P3: RZ7.1; also elsewhere on the board
GND: C77.P$2 (2), C78.P$2 (2), J1.5 (GND), J1.B5 (GND), J2.5 (GND), J2.B5 (GND), RZ6.2, RZ7.2, RZ8.2, VR2.2 (GND), VR2.PAD (GND); also elsewhere on the board
LED_SUP: D1.A1, D1.A2, D2.A1, D2.A2, JP1.1; also elsewhere on the board
VDDAUDA_1P8-CLEAN: RZ11.2; also elsewhere on the board
VR2_EN: RZ10.2, VR2.3 (EN)
VR2_OUT: C78.P$1 (1), RZ11.1, VR2.1 (OUT)

Notes on the sheet:
Ambiq Eng Note— VDDAUDA must be powered (even if not using BLE or AUDADC). I see you have an enable triggered by a pin. Note this can cause issues.
datasheet est's Rdrp =Ω If tgt: 20 mA ~~cheap 0402 R's dissp limit 10mW~~ 1.8 SUPPLY 2.5 SUPPLY Vf red: 1.5 0.3V 15Ω 6mW 1.0V 50Ω 20mW Vf grn: 1.7 0.1V 5Ω 2mW 0.8V 40Ω 16mW Vf blu: 1.7 0.1V 5Ω 2mW 0.8V 40Ω 16mW

Schematic: rev_n v35.sch, sheet 1, Power

Parts:
C7, C8: 22pF; 0201_CAP; MPN GRM0335C1H220FA01D
C9, C10: 470pF; 0402_CAP; MPN GRM1555C1H471JA01J; DIGIKEY 490-6242-1-ND
C15, C16: 10nF; 0402_CAP; MPN GRM155R71H103KA88J; DIGIKEY 490-6351-2-ND
C17, C18, C19: 22nF; 0402_CAP; MPN GRM155R71E223JA61D; DIGIKEY 490-10699-2-ND
C20, C21: 22nF; 0402_CAP; MPN CC0402ZRY5V8BB223; DIGIKEY 311-3823-1-ND
C27, C28, C29, C30: 0.1uF; 0402_CAP; MPN GRM155R71C104KA88J; DIGIKEY 490-6328-1-ND
C38, C39: 0.47uF; 0402_CAP; MPN GRT155R61E474ME01D; DIGIKEY 490-12270-1-ND
C40, C41, C42: 1uF; 0402_CAP; MPN GRM155R70J105KA12J
C45, C46, C47, C48: 4.7uF; 0603_CAP; MPN C1608X7S1A475K080AC
C53, C56, C57: 10uF; 0603_CAP; MPN CM105X5R106M25AT; DIGIKEY 1253-CM105X5R106M25ATCT-ND
J3: PINHD-1X2; 1X02
J4: MOLEX-PICO-SPOX-3SIDE; MOLEX-PICO-SPOX-3_SIDE
J5, J6: PINHD-1X1; 1X01
L1, L2: 10uH; NRX3015; MPN NR3015T100M
L4: WURTH_COIL_760308103204
Q1: CSD75207W15; DSBGA
R6, R7: 97.6; 0402_RES; MPN RMCF0402FT97R6; DIGIKEY RMCF0402FT97R6CT-ND
R8, R9: 162; 0402_RES; MPN RMCF0402FT162R; DIGIKEY RMCF0402FT162RCT-ND
R13, R15: 2.2k; 0402_RES; MPN RC0402FR-072K2L
R18, R23: 10k; 0402_RES; MPN RC0402JR-0710KL; DIGIKEY 311-10KJRCT-ND
R26: 261k; 0201_RES; MPN ERJ-1GNF2613C
R27: 402k; 0201_RES; MPN ERJ-1GNF4023C
R28, R29: 845k; 0201_RES; MPN ERJ-1GNF8453C
R30: 1.87M; 0402_RES; TOLERANCE 1%; MPN RMCF0402FT1M87
R31: 5.1M; 0402_RES; TOLERANCE 1%; MPN RMCF0402FT5M10; DIGIKEY RMCF0402FT5M10CT-ND
R33, R34: 5.1M; 0402_RES; MPN RMCF0402FT5M10; DIGIKEY RMCF0402FT5M10CT-ND
RT1: 10k@25C; 0402_RES; MPN NCU15XH103F60RC; DIGIKEY 490-18149-1-ND
RX7, RX14: DNP; 0402_RES
S1: 450404015514; DIGIKEY 732-13665-1-ND
SJ2: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
U3: BQ24040; DSQ0010A
U4: BQ51013B; RHL0020A
VR1: RT8020RT8020GQW; SON45P300X300X80-13T160X250N
XJ1: USB4110-GF-A; GCT_USB4110-GF-A
XR16, XR17: 5.1k; 0402_RES; MPN RMCF0402FT5K10; DIGIKEY RMCF0402FT5K10CT-ND
XR19: 10k; 0402_RES; MPN RC0402JR-0710KL; DIGIKEY 311-10KJRCT-ND

Connections:
!AD_EN: Q1.A1 (G1), Q1.C1 (G2), U4.8 (!AD-EN)
+2V5: C7.P$1 (1), C47.2, J5.1, L1.P$2 (2), R28.2; also elsewhere on the board
AP4_GP18/TT_BATIN: C27.1, R30.2, R31.1; also elsewhere on the board
AP4_GP58/TT_!CHG: U3.8 (!CHG), U4.7 (!CHG); also elsewhere on the board
AP4_GP60/TT_!PG: U3.5 (!PG); also elsewhere on the board
AP4_GP66/TT_QI_TS_CTRL: C30.1, RT1.2, U4.13 (TS/CTRL); also elsewhere on the board
BATT_THERM: J4.2, J4.2SUPP (2), SJ2.3; also elsewhere on the board
BATT_TS: SJ2.2, U3.9 (TS); also elsewhere on the board
BQ_AC1: C9.1, C10.1, C15.2, C17.1, C18.1, C19.1, C20.2, C38.2, U4.2 (AC1)
BQ_AC2: C9.2, C10.2, C16.2, C21.2, C39.2, L4.P$2 (2), U4.19 (AC2)
BQ_BOOT1: C15.1, U4.3 (BOOT1)
BQ_BOOT2: C16.1, U4.17 (BOOT2)
BQ_CLAMP1: C38.1, U4.5 (CLAMP1)
BQ_CLAMP2: C39.1, U4.16 (CLAMP2)
BQ_COMM1: C20.1, U4.6 (COMM1)
BQ_COMM2: C21.1, U4.15 (COMM2)
BQ_FOD: R7.1, R9.2, R23.2, U4.14 (FOD)
BQ_ILM: R8.1, U4.12 (ILIM)
BQ_ISET: R15.2, U3.2 (ISET)
BQ_RECT: C28.1, C56.1, C57.1, R18.1, U4.18 (RECT)
COIL_AC1: C17.2, C18.2, C19.2, L4.P$1 (1)
D+: XJ1.A6 (DP1), XJ1.B6 (DP2)
D-: XJ1.A7 (DN1), XJ1.B7 (DN2)
GND: C27.2, C28.2, C29.2, C30.2, C40.1, C41.2, C42.2, C45.1, C46.2, C47.1, C48.2, C53.2, C56.2, C57.2, J3.2 (SWDIO), J4.1, J4.1SUPP (1), R6.2, R15.1, R26.1, R27.1, R30.1, RX7.1, RX14.1, U3.3 (VSS), U3.7 (ISET2), U3.PAD (VSS), U4.1 (PGND), U4.10 (EN1), U4.11 (EN2), U4.20 (PGND), U4.PAD (PGND), VR1.3 (GND2), VR1.9 (GND1), VR1.13 (GND2), XJ1.A1/B12 (GND), XJ1.B1/A12 (GND), XJ1.S1 (GND), XJ1.S2 (GND), XJ1.S3 (GND), XJ1.S4 (GND), XR16.2, XR17.2, XR19.1; also elsewhere on the board
unnamed: R6.1, R7.2
unnamed 122: SJ2.1, XR19.2; also elsewhere on the board
unnamed: RX7.2, U3.4 (PRETERM)
unnamed: R18.2, R23.1
unnamed: R8.2, R9.1
unnamed: R13.2, RT1.1
unnamed 127: R13.1, RX14.2; also elsewhere on the board
VBAT: C42.1, J3.1 (VTREF), J4.3, J4.3SUPP (3), S1.2, U3.10 (OUT); also elsewhere on the board
VBAT_SWITCHED: C45.2, C48.1, R31.2, R33.1, R34.1, S1.3, VR1.1 (VIN2), VR1.7 (VIN1)
VQI: C29.1, C41.1, C53.1, Q1.A2 (D1), Q1.A3 (D1), Q1.B3 (D1), U3.1 (IN), U4.4 (OUT)
VR1_1P8_EN: R34.2, VR1.6 (EN1)
VR1_2P5_EN: R33.2, VR1.12 (EN2)
VR1_FB1: C8.P$1 (1), R27.2, R29.2, VR1.4 (FB1)
VR1_FB2: C7.P$2 (2), R26.2, R28.1, VR1.10 (FB2)
VR1_LX1: L2.P$2 (2), VR1.8 (LX1)
VR1_LX2: L1.P$1 (1), VR1.2 (LX2)
VUSB: C40.2, Q1.B2 (D2), Q1.C2 (D2), Q1.C3 (D2), U4.9 (AD), XJ1.A4/B9 (VBUS), XJ1.B4/A9 (VBUS)

Notes on the sheet:
2.5V Rail DW.VDD2 88 mA (100) LNA 10.6 mA 9DOF 12.3 mA (15) Buzzer 90 mA (150) ------------------------ 200.9 mA (265) 40%I->L: 6.5 uH ( 9.2) ∆IL 85 mA (120) COUT=4.7uF, ESR@1.5MHz=0.005 ∆Vout 1.9 mV ( 2.7) ** After ^math, moved the VDDAUDA LDO from battery to hang off 2.5V for routing [plus some e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
1.8V Rail DW.VDD1 10 mA (10) DW.VDD3 70 mA (100) Flash 35 mA (50) 9DOF 12.3 mA (15) Apollo4 11.3 mA (120) ------------------------ 141.6 (295) 40%I->L: 5.8 uH ( 11.3) ∆IL 68 mA (132) COUT=4.7uF, ESR@1.5MHz=0.005 ∆Vout 1.5 mV ( 3)
Vout = Vref * (1 + R1/R2) Vref=0.6V, R1=850kΩ R2 = 850e3/((2.5/.6)-1) = 268.4kΩ R2 = 850e3/((1.875/.6)-1) = 400.0kΩ Note: 1.8 -> 1.875 to balance buffer above 1.8~1.85 for AP4 and below the hard max of 1.95 for the flash chip
Switch Current Rating: 250 mA (Assume 90% eff) 2.5: (150*2.5)/(3.4*.9) = 125 1.8: (200*1.8)/(3.4*.9) = 120
Actual: 402k -> 1.8687V
Actual: 261k -> 2.554V

Schematic: rev_n v35.sch, sheet 2, Flash, 9-DOF, Buzzer

Parts:
C5, C6: 4pF; 0201_CAP; MPN GRM0335C1H4R0BA01D
C31, C32, C35, C36: 0.1uF; 0402_CAP; MPN CL05A104KP5NNNC
C44: 1uF; 0402_CAP; MPN GRM155R70J105KA12J
D4: DIODE0402; 0402_DIODE; MPN CDSQR400B-HF; DIGIKEY 641-2087-1-ND
LS1: PUI_SMT-0440-T-2-R; SMT-0440-T-2-R
Q2: MOSFET-NCHANNELXFDN-3; XFDFN-3
R12, R16, R20: 10k; 0402_RES; MPN RC0402JR-0710KL; DIGIKEY 311-10KJRCT-ND
R25: 100k; 0402_RES; MPN RT0402BRE07100KL
RX2, RX5, RX6, RX8: DNP; 0603-RES
SJ5, SJ6, SJ7: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
U6: BNO086; LGA28R0P510X4_5P2X3P8X1
U8: AS5FXXX04SND; AS5FXXXXXXXX-XXLXN
X2: TXC-9HT12; MPN 9HT12-32.768KDZY-T

Connections:
9DOF_CAP: C36.1, U6.9 (CAP)
9DOF_XI: C5.P$2 (2), U6.27 (XIN32), X2.2
9DOF_XO: C6.P$2 (2), U6.26 (XOUT32/CLKSEL1), X2.1
+2V5: C32.1, C44.1, D4.CATHODE, LS1.+, U6.3 (VDD); also elsewhere on the board
AP4_GP06/TT_FLASH_!HOLD_IO3: U8.7 (!HOLD!/SIO3); also elsewhere on the board
AP4_GP08/TT_9DOF_H_SCL/SCK/RX: RX6.2, U6.19 (H_SCL/SCK/RX); also elsewhere on the board
AP4_GP13/TT_9DOF_!BOOT: R20.1, U6.4 (!BOOT); also elsewhere on the board
AP4_GP17/TT_9DOF_H_!INT: U6.14 (H_INTN); also elsewhere on the board
AP4_GP30/TT_FLASH_!WP: U8.3 (!WP!/SIO2); also elsewhere on the board
AP4_GP47/TT_FLASH_SCK: U8.6 (SCLK); also elsewhere on the board
AP4_GP48/TT_FLASH_PDI_IO0: U8.5 (SI/SIO0); also elsewhere on the board
AP4_GP49/TT_FLASH_PDO_IO1: U8.2 (SO/SIO1); also elsewhere on the board
AP4_GP55/TT_BUZZER_GATE: Q2.G, R25.1; also elsewhere on the board
AP4_GP63/TT_9DOF_PS0/WAKE: U6.6 (PS0/WAKE); also elsewhere on the board
AP4_GP65/TT_9DOF_!RESET: RX8.1, U6.11 (!RESET); also elsewhere on the board
AP4_GP69/TT_FLASH_!CS: RX2.1, U8.1 (!CS); also elsewhere on the board
AP4_GP72/TT_9DOF_H_!CS: U6.18 (H_!CS); also elsewhere on the board
BNO_ENV_SCL: R12.1, U6.15 (ENV_SCL)
BNO_ENV_SDA: R16.1, U6.16 (ENV_SDA)
BNO_PS1: SJ7.2, U6.5 (PS1); also elsewhere on the board
GND: C5.P$1 (1), C6.P$1 (1), C31.2, C32.2, C35.2, C36.2, C44.2, Q2.S, R25.2, SJ7.1, U6.2 (GND), U6.10 (CLKSEL0), U6.25 (GNDIO), U8.4 (GND); also elsewhere on the board
unnamed: D4.ANODE, LS1.- (N), Q2.D

Notes on the sheet:
Sup 1.7 - 1.98 V Qui 30 µA Max 30 mA
VDD 2.4 - 3.6 V, max 8 mA, qui 0.1 mA VDDIO 1.7 - 3.6 V, max 7 mA, qui 0.047 mA
Sup 2 - 4 V Nom 3 V Max 90 mA [50% DC]
If separate GNDIO ever relevant..
Datasheet— Does not give C int.. Digital pads typ 5pf, max 10pf CL = (C*C)/(C+C+) + Cstray C = 4 w/ only pads, as Cstray goes up, C rises, 4pF on should be okay
SEL0==GND -> XTAL
PS1 PS0 0 0 I2C 0 1 UART-RVC 1 0 UART 1 1 SPI
Switch SJ5, SJ6, and SJ7 for I2C

Schematic: rev_n v35.sch, sheet 3, Localization module

Parts:
A1, A2, A3: ACR0301U
C2: 2pF; 0201_CAP; MPN CBR02C209A5GAC
C3, C4: 3.3pF; SMD_2012M-0805US-C; MPN 600F3R3BT250XT
C11: 0.1uF; SMD_3216M-1206US-C; MPN GRM31C5C1H104JA01L
C12, C13, C14: 4.7nF; SMD_1608M-0603US-C; MPN C0603C472J5GAC7867
C22, C24: 0.1uF; SMD_1608M-0603US-C; MPN C1608X7R1H104K080AA
C23, C25, C26, C33, C34: 0.1uF; 0402_CAP; MPN CL05A104KP5NNNC
C37: 0.22uF; SMD_1608M-0603US-C; MPN C1608X7R1H224K080AB
C43: 100pF; SMD_1005M-0402US-C; MPN C0402C101J3GACTU
C49, C50: 4.7uF; 0603_CAP; MPN C1608X7S1A475K080AC
C54, C55: 10uF; SMD_1608M-0603US-C; MPN CM105X5R106M25AT
C90, C91: 1uF; 0201_CAP; MPN GRM033R61A105ME44D
CX1, CX2: DNP; 0603_CAP
FB1: BLM03PG330SN1D; 0201_FB; MPN BLM03PG330SN1D
R1: 49.9-1%; 0201_RES; MPN ERJ-1GNF49R9C
R24: 100k; 0402_RES; MPN RT0402BRE07100KL
RX1: DNP; 0603-RES
RZ1, RZ2: 0; 0603-RES; MPN RMCF0603ZT0R00
RZ4: 0; 0402_RES; MPN RMCF0402ZT0R00
S2: SKY13373
S3: SIP3241XSIP32414; TDFN2X2X0P6-8
S4: MM8030-2610
SJ3, SJ4: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
TP0, TP1, TP2, TP3, TP4, TP5, TP6, TP7: TEST-POINT; PAD.03X.03
U2: DW3110; WLCSP52
U7: QM14068
VR3: TPS7A0218PDQNR; 4-XDFN-EP
X4: TXC-8Y; MPN 8Y38472012

Connections:
+2V5: C34.1, C49.1, C90.P$1 (1), RX1.1, S2.6 (VDD), S3.1 (IN), VR3.4 (IN); also elsewhere on the board
ANT1: A1.FEED, U7.2 (LNA_IN)
AP4_GP14/TT_!DW_SPI_CS: U2.B5 (!SPICS); also elsewhere on the board
AP4_GP24/TT_RFSW_V1: CX2.1, S2.4 (V1); also elsewhere on the board
AP4_GP25/TT_RFSW_V2: CX1.1, S2.5 (V2); also elsewhere on the board
AP4_GP26/TT_DW_WAKEUP: U2.B9 (WAKEUP); also elsewhere on the board
AP4_GP27/TT_DW_IRQ: R24.2, U2.B1 (IRQ/GPIO8); also elsewhere on the board
AP4_GP31/TT_DW_SPI_CLK: U2.A8 (SPICLK); also elsewhere on the board
AP4_GP32/TT_DW_SPI_IO0: U2.B7 (SPICDI(MOSI)); also elsewhere on the board
AP4_GP33/TT_DW_SPI_IO1: U2.A6 (SPICDO(MISO)); also elsewhere on the board
AP4_GP50/TT_!DW_RESET: U2.A10 (!RST); also elsewhere on the board
DW_EXTON: RX1.2, S3.2 (CTL), S3.3 (CTL), SJ4.2, VR3.3 (EN); also elsewhere on the board
DW_EXTON_RAW: SJ4.3, U2.A12 (EXTON); also elsewhere on the board
DW_GPIO4: TP4.P$1, U2.F1 (GPIO4/EXTPA)
DW_GPIO5: TP5.P$1, U2.D1 (GPIO5/EXTTXE/SPIPOL)
DW_GPIO6/EXTRXE: SJ3.3, TP6.P$1, U2.C4 (GPIO6/EXTRXE/SPIPHA); also elsewhere on the board
DW_RF1: C2.P$1 (1), U2.H11 (RF1)
DW_RF2: R1.1, U2.H5 (RF2)
DW_RXLED: TP2.P$1, U2.E4 (GPIO2/RXLED)
DW_RXOKLED: TP0.P$1, U2.C2 (GPIO0/RXOKLED)
DW_SFDLED: TP1.P$1, U2.D3 (GPIO1/SFDLED)
DW_SYNC: TP7.P$1, U2.G2 (GPIO7/SYNC)
DW_TXLED: TP3.P$1, U2.E2 (GPIO3/TXLED)
DW_VDD2A: C12.P$1, FB1.P$2, U2.F15 (VDD2A)
DW_VDD2_PWROUT: C33.1, RZ1.1, S3.8 (OUT)
DW_VDD2_SUP: C13.P$1, C24.P$1, C55.P$1, FB1.P$1, RZ1.2, U2.B15 (VDD2B)
DW_VDD3_PWROUT: C25.1, RZ2.1, S3.5 (OUT)
DW_VDD3_SUP: C14.P$2, C22.P$2, C54.P$2, RZ2.2, U2.D15 (VDD3)
DW_VIO_D: C23.1, U2.A4 (VIO_D)
DW_VTX_D: C37.P$2, U2.C14 (VTX_D)
DW_XT0: C4.P$1, U2.G14 (XTO), X4.3 (2)
DW_XTI: C3.P$1, U2.H15 (XTI), X4.1
GND: C3.P$2, C4.P$2, C11.P$2, C12.P$2, C13.P$2, C14.P$1, C22.P$1, C23.2, C24.P$2, C25.2, C26.2, C33.2, C34.2, C37.P$1, C43.P$2, C49.2, C50.1, C54.P$1, C55.P$2, C90.P$2 (2), C91.P$2 (2), CX1.2, CX2.2, R1.2, R24.1, S2.2 (GND), S2.7 (GND), S2.8 (GND), S2.10 (GND), S2.12 (GND), S2.PAD (GND), S3.6 (GND), S3.7 (GND), S3.PAD (GND), S4.G1 (GND), S4.G2 (GND), SJ3.1, U2.A2 (VSS), U2.A14 (VSS1), U2.B3 (VSS), U2.B11 (VSS1), U2.C6 (VSS), U2.C8 (VSS1), U2.C10 (VSS1), U2.C12 (VSS3), U2.D5 (VSS), U2.D7 (VSS), U2.D9 (VSS1), U2.D11 (VSS2), U2.D13 (VSS3), U2.E6 (GND-RF), U2.E10 (GND-RF), U2.E12 (GND-RF), U2.E14 (VSS2), U2.F7 (GND-RF), U2.F9 (GND-RF), U2.G6 (GND-RF), U2.G10 (GND-RF), U2.H1 (GND-RF), U2.H3 (GND-RF), U2.H7 (GND-RF), U2.H9 (GND-RF), U2.H13 (GND-RF), U7.3 (GND), U7.4 (GND), U7.5 (GND), U7.7 (GND), U7.9 (GND), VR3.2 (GND), VR3.PAD (GND), X4.2 (GND), X4.4 (GND); also elsewhere on the board
LNA_VCTRL: SJ3.2, U7.8 (VCTRL); also elsewhere on the board
RF1: S2.9 (J2), U7.6 (LNA_OUT)
RF2: A2.FEED, S2.3 (J3)
RF3: A3.FEED, S2.1 (J1), S4.IN, S4.OUT (A)
RFC: C2.P$2 (2), S2.11 (RFC)
VDD_LNA: C11.P$1, C43.P$1, RZ4.2, U7.1 (VDD)
VR3_OUT: C91.P$1 (1), RZ4.1, VR3.1 (OUT)

Notes on the sheet:
Supply 2.4 - 3.6 V ds #'s @ 3.0 V min typ max VDD1 1.6 3.0 3.6 VDD2a,b 2.4 3.0 3.6 VDD3 1.5 3.0 3.6 Voltage on GPIO0-5, WAKEUP, RSTn, SPICSn, SPIMOSI, SPICLK -> Max: VDD1+0.3V I/O current (max): 10 mA VDD1 -> I/O Peak cont current is RX CH9: 88 mA TX worst-case: VDD2a/b: 20 mA VDD3: 20 mA RX worst-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
SupV 2.5-4.8 I/O V 1.65-min(3.3,SupV) Active: 60 µA Qui: 5 µA
V1 V2 State 0 0 Shutdown 1 0 RFC<>J2 0 1 RFC<>J1 1 1 RFC<>J3
Datasheet says no passives are needed However, EVB sch has 100 pF filters. Add hedge for option
Hedge: Allow disabling of low-power mode

Schematic: rev_n v35.sch, sheet 4, External signals

Parts:
FD1, FD2, FD4, FD6: FIDUCIAL; FIDUCIAL_1MM-CU_2MM-MASK

Notes on the sheet:
Miscellany
Fiducials - Top
Fiducials - Bottom

Schematic: rev_n v35.sch, sheet 5, Apollo4 IC

Parts:
A4: AMCA72-2R47G-S1F-T; AMCA72-2R470G-S1F-T
C1: 1.5pF; CAPC1005X60; TOLERANCE +/- 0.25pF; MPN C0402C159C5GACTU
C58, C59, C60, C61, C66, C67, C70, C71, C72, C73, C74, C75: 2.2uF; 0201_CAP; MPN GRM033R61A225KE47D
C62, C63, C64, C65, C79, C93: 1uF; 0201_CAP; MPN GRM033R61A105ME44D
C69: 4.7uF; 0402_CAP; MPN CL05A475MP5NRNC
C76: 4700pF; CAPC1005X60; MPN KGM05AR71E472KH
C80, C81: 6pF; CAPC1005X60; MPN GCM1555C1H6R0BA16D
CX3, CX4, CX5: DNP; CAPC1005X60
D3: ZENER; SODFL1608X70; MPN PESD5V0X1UB,135
L5: 2.2µH; 0805_CAP; MPN DFE201210U-2R2M=P2
L6: 1.0µH; 0603_CAP; MPN DFE18SAN1R0ME0L
L7: 2.0nH; INDC1006X60N; TOLERANCE +/- 0.1 nH; MPN LQG15HS2N0B02D
L8: 2.2nH; INDC1006X60N; TOLERANCE +/- 0.1 nH; MPN LQG15HN2N2B02D
RZ9: 0; 0402_RES; MPN RMCF0402ZT0R00
TP8: VDDBH; PAD.03X.03
TP9: VDDP; PAD.03X.03
TP10: VDDF; PAD.03X.03
U1: APOLLO4_BLUE_PLUS_SOC_KBR; APOLLO4_BLUE_SOC_BGA
X1: ABM12W; MPN ABM12W-32.0000MHZ-6-D1X-T3
X3: TXC-9HT12; MPN 9HT12-32.768KDZY-T

Connections:
AGND: C1.2, C93.P$2 (2), CX5.2, U1.M1 (RFIOM), U1.M3 (RFSUB-RF_SUBSTRATE_GND)
AP4_!RESET: C76.1, D3.1 (C), U1.A6 (!RST); also elsewhere on the board
AP4_GP06/TT_FLASH_!HOLD_IO3: U1.J5 (GPIO6); also elsewhere on the board
AP4_GP08/TT_9DOF_H_SCL/SCK/RX: U1.H2 (GPIO31); also elsewhere on the board
AP4_GP13/TT_9DOF_!BOOT: U1.D5 (GPIO13); also elsewhere on the board
AP4_GP14/TT_!DW_SPI_CS: U1.D6 (GPIO14); also elsewhere on the board
AP4_GP17/TT_9DOF_H_!INT: U1.D4 (GPIO17); also elsewhere on the board
AP4_GP18/TT_BATIN: U1.D3 (GPIO18); also elsewhere on the board
AP4_GP24/TT_RFSW_V1: U1.E2 (GPIO24); also elsewhere on the board
AP4_GP25/TT_RFSW_V2: U1.K5 (GPIO25); also elsewhere on the board
AP4_GP26/TT_DW_WAKEUP: U1.L5 (GPIO26); also elsewhere on the board
AP4_GP27/TT_DW_IRQ: U1.M5 (GPIO27); also elsewhere on the board
AP4_GP30/TT_FLASH_!WP: U1.G4 (GPIO30); also elsewhere on the board
AP4_GP31/TT_DW_SPI_CLK: U1.E8 (GPIO8); also elsewhere on the board
AP4_GP32/TT_DW_SPI_IO0: U1.E7 (GPIO9); also elsewhere on the board
AP4_GP33/TT_DW_SPI_IO1: U1.E6 (GPIO10); also elsewhere on the board
AP4_GP47/TT_FLASH_SCK: U1.F1 (GPIO47); also elsewhere on the board
AP4_GP48/TT_FLASH_PDI_IO0: U1.E1 (GPIO48); also elsewhere on the board
AP4_GP49/TT_FLASH_PDO_IO1: U1.D1 (GPIO49); also elsewhere on the board
AP4_GP50/TT_!DW_RESET: U1.A9 (GPIO50); also elsewhere on the board
AP4_GP51/LED1_GREEN: U1.B9 (GPIO51); also elsewhere on the board
AP4_GP53/LED1_RED: U1.C9 (GPIO53); also elsewhere on the board
AP4_GP55/TT_BUZZER_GATE: U1.D9 (GPIO55); also elsewhere on the board
AP4_GP58/TT_!CHG: U1.J7 (GPIO58); also elsewhere on the board
AP4_GP60/TT_!PG: U1.K8 (GPIO60); also elsewhere on the board
AP4_GP63/TT_9DOF_PS0/WAKE: U1.M6 (GPIO63); also elsewhere on the board
AP4_GP65/TT_9DOF_!RESET: U1.A7 (GPIO65); also elsewhere on the board
AP4_GP66/TT_QI_TS_CTRL: U1.A8 (GPIO66); also elsewhere on the board
AP4_GP69/TT_FLASH_!CS: U1.B8 (GPIO69); also elsewhere on the board
AP4_GP72/TT_9DOF_H_!CS: U1.C8 (GPIO72); also elsewhere on the board
AP4_GP79/LED2_RED: U1.M11 (GPIO79); also elsewhere on the board
AP4_GP88/LED2_YLW: U1.F9 (GPIO88); also elsewhere on the board
AP4_LPADC_VREF: C79.P$2 (2), U1.A12 (LPADC_VREF)
AP4_LPMICBIAS: C71.P$2 (2), U1.B10 (LPMICBIAS)
AP4_RFIOP1: CX5.1, L7.1, U1.M2 (RFIOP)
AP4_SWDCLK: U1.K3 (GPIO20); also elsewhere on the board
AP4_SWDIO: U1.J3 (GPIO21); also elsewhere on the board
AP4_SWO: U1.L4 (GPIO3); also elsewhere on the board
AP4_USB0_N: U1.M8 (USB0PN)
AP4_USB0_P: U1.M7 (USB0PP)
AP4_VDDBH: C69.1, L6.2, RZ9.1, TP8.P$1, U1.G12 (VDDBH--BLE_BUCK_VOUT)
AP4_VDDBH_RF: C93.P$1 (1), RZ9.2, U1.J1 (VDDBH_RF--BLE_BUCK_RF_VOUT)
AP4_VDDBH_SW: L6.1, U1.H12 (VDDBH_SW--BLE_BUCK_SW)
AP4_VDDC: C59.P$1 (1), U1.A3 (VDDC-CORE)
AP4_VDDC_LV: C60.P$1 (1), U1.B3 (VDDC_LV-CORE_LV)
AP4_VDDF: C61.P$1 (1), C75.P$1 (1), TP10.P$1, U1.C2 (VDDF-MEM)
AP4_VDDMIPI_1P8: C70.P$1 (1), U1.H10 (VDD18-MIPI); also elsewhere on the board
AP4_VDDS: C58.P$1 (1), U1.C1 (VDDS-SRAM_HV_SUP)
AP4_VDDUSB_0P9: C73.P$1 (1), U1.L7 (VDDUSB0P9); also elsewhere on the board
AP4_VDDUSB_3P3: C74.P$1 (1), U1.K7 (VDDUSB33); also elsewhere on the board
AP4_XI: C81.1, U1.A4 (XI), X3.2
AP4_XI32M: CX4.1, U1.C12 (XI32M), X1.3 (2)
AP4_XO: C80.1, U1.A5 (XO), X3.1
AP4_XO32M: CX3.1, U1.D12 (XO32M), X1.1
BLE_RFOUT: A4.S1, L8.2
GND: C58.P$2 (2), C59.P$2 (2), C60.P$2 (2), C61.P$2 (2), C62.P$2 (2), C63.P$2 (2), C64.P$2 (2), C65.P$2 (2), C66.P$2 (2), C67.P$2 (2), C69.2, C70.P$2 (2), C71.P$1 (1), C72.P$2 (2), C73.P$2 (2), C74.P$2 (2), C76.2, C79.P$1 (1), C80.2, C81.2, CX3.2, CX4.2, D3.2 (A), U1.B2 (VSSP-BUCK_REGS_GND), U1.B5 (VSSA-ANALOG_GND), U1.B12 (VSSAUDA), U1.D2 (VSS-DGND_FOR_VDDF_AND_PADS), U1.E12 (VSSAUDD), U1.H1 (VSSB-BLE_UNREG_GND), U1.J10 (VSS18-MIPI), U1.L1 (VSSVCO-BLECORE_GND_FOR_VCO), U1.L2 (VSSS-HVSIMOBUCK_GND), U1.L8 (VSSAUSB), X1.2 (GND), X1.4 (GND); also elsewhere on the board
unnamed: C1.1, L7.2, L8.1
SIMOBUCK_SW: L5.P$1 (1), U1.A1 (SIMOBUCK_SW)
SIMOBUCK_SWSEL: L5.P$2 (2), U1.A2 (SIMOBUCK_SWSEL)
VDDAUDA_1P8-CLEAN: C72.P$1 (1), U1.B11 (VDDAUDA); also elsewhere on the board

Notes on the sheet:
Supply 1.8-2.0 V M4 max sust: 4 mA Buck spikes: 100 mA BLE max sus: 6 mA (+1.2?) BLE buck spk: 2.2 mA
Note: Load caps DNP on Ambiq reference assembly
Int PUs, safe float
If Unused: Float data; gnd usb pwr
If Unused (no display): Float clk,data; gnd pwr
Unused (no mic yet..) Float inputs and bias out VRef always gen'd internally and expects 100nF cap
No idea what this does :( Datasheet doesn't explain anywhere. Reference board just pins out to general header
I/O Planning Notes
3 MSPI instances - MSPI0 seems normal, use → GPIO64-73 (PadFn0) - MSPI1-2 have many caveats, avoid
7 IOM (I2C/SPI), two power domains - IOM0-3 HCPB - IOM5-7 HCPC IOMn_SUBMODCTRL_SMODnEN reg disables submodule
MSPI0
IOM0
IOM1
Timers (PWM/buzzer) any GPIO pin (Pad Fn6)
KBR Package
For the KBR package of the Apollo4 Blue Plus SoC, the pins available for chip enables for the MSPI instances are limited to: GPIO14, 52, 56, 57, 60, 73, 75, 83, 84, 85, 86 and 91.
§30.2.4-6 Recommended Buck,Bypass,Ext Components
SWD Pins (req)
VREF generated internally, ext cap is filter
IOM3
AP4 datasheet— XI/XO int C: 3.4pF max ext C: 7 pF
AP4 datasheet— XI/XO int C: 3.4pF C-load: 6 pF (max) ESR: 100 Ω
Pad Fn4
Pad Fn2
Pad Fn0
Note: Load caps DNP after first-gen fab testing. EVB Populates with 6pF
Route USB0PN and USB0PP as 90Ω differential pair
Route CLKN, CLKP as 100Ω diff pair and 50Ω single-ended trcs
Route D0N and D0P as 100Ω diff pair and 50Ω signle-ended trcs
NOTE: EVB and ref sch have a 0.1uF here. As this is unused, replaced with 1uF to reduce BOM count.
IOM2
IOM5
IOM6
IOM7

Schematic: rev_n v35.sch, sheet 6, AP4 Support Circuits

Parts:
C77, C78: 1uF; 0201_CAP; MPN GRM033R61A105ME44D
D1: BICOLOR-SMD; LED-0606; MPN MCL0606FRD1GR1T
D2: BICOLOR-SMD; LED-0606; MPN MCL0606FYW1RD1T
J1, J2: TC2030-JLINK-NL-2SIDE; TC2030-IDC-NL-2SIDE
R2, R3: 5.1; 0402_RES; MPN RC0402JR-075R1L
R4, R5: 15; 0402_RES; MPN RC0402JR-0715RL
RZ6, RZ7, RZ8, RZ10, RZ11: 0; 0402_RES; MPN RMCF0402ZT0R00
SJ1: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
VR2: TPS7A0218PDQNR; 4-XDFN-EP

Connections:
+2V5: C77.P$1 (1), RZ10.1, VR2.4 (IN); also elsewhere on the board
AP4_!RESET: J1.3 (!RESET), J1.B3 (!RESET); also elsewhere on the board
AP4_GP51/LED1_GREEN: R2.2; also elsewhere on the board
AP4_GP53/LED1_RED: R5.2; also elsewhere on the board
AP4_GP79/LED2_RED: R4.2; also elsewhere on the board
AP4_GP88/LED2_YLW: R3.2; also elsewhere on the board
AP4_LED2_BLUE_COMM: D1.C1, R5.1
AP4_LED_BLUE_COMM: D2.C2, R3.1
AP4_LED_GREEN_COMM: D2.C1, R4.1
AP4_LED_RED_COMM: D1.C2, R2.1
AP4_SWDCLK: J1.4 (SWDCLK), J1.B4 (SWDCLK); also elsewhere on the board
AP4_SWDIO: J1.2 (SWDIO), J1.B2 (SWDIO); also elsewhere on the board
AP4_SWO: J1.6 (SWO), J1.B6 (SWO); also elsewhere on the board
AP4_VDDMIPI_1P8: RZ8.1; also elsewhere on the board
AP4_VDDUSB_0P9: RZ6.1; also elsewhere on the board
AP4_VDDUSB_3P3: RZ7.1; also elsewhere on the board
GND: C77.P$2 (2), C78.P$2 (2), J1.5 (GND), J1.B5 (GND), J2.5 (GND), J2.B5 (GND), RZ6.2, RZ7.2, RZ8.2, VR2.2 (GND), VR2.PAD (GND); also elsewhere on the board
LED_SUP: D1.A1, D1.A2, D2.A1, D2.A2, SJ1.1; also elsewhere on the board
VDDAUDA_1P8-CLEAN: RZ11.2; also elsewhere on the board
VR2_EN: RZ10.2, VR2.3 (EN)
VR2_OUT: C78.P$1 (1), RZ11.1, VR2.1 (OUT)

Notes on the sheet:
Ambiq Eng Note— VDDAUDA must be powered (even if not using BLE or AUDADC). I see you have an enable triggered by a pin. Note this can cause issues.
datasheet est's Rdrp =Ω If tgt: 20 mA ~~cheap 0402 R's dissp limit 10mW~~ 1.8 SUPPLY 2.5 SUPPLY Vf red: 1.5 0.3V 15Ω 6mW 1.0V 50Ω 20mW Vf grn: 1.7 0.1V 5Ω 2mW 0.8V 40Ω 16mW Vf blu: 1.7 0.1V 5Ω 2mW 0.8V 40Ω 16mW

Schematic: rev_n v36.sch, sheet 1, Power

Parts:
C7, C8: 22pF; 0201_CAP; MPN GRM0335C1H220FA01D
C9, C10: 470pF; 0402_CAP; MPN GRM1555C1H471JA01J; DIGIKEY 490-6242-1-ND
C15, C16: 10nF; 0402_CAP; MPN GRM155R71H103KA88J; DIGIKEY 490-6351-2-ND
C17, C18, C19: 22nF; 0402_CAP; MPN GRM155R71E223JA61D; DIGIKEY 490-10699-2-ND
C20, C21: 22nF; 0402_CAP; MPN CC0402ZRY5V8BB223; DIGIKEY 311-3823-1-ND
C27, C28, C29, C30: 0.1uF; 0402_CAP; MPN GRM155R71C104KA88J; DIGIKEY 490-6328-1-ND
C38, C39: 0.47uF; 0402_CAP; MPN GRT155R61E474ME01D; DIGIKEY 490-12270-1-ND
C40, C41, C42: 1uF; 0402_CAP; MPN GRM155R70J105KA12J
C45, C46, C47, C48: 4.7uF; 0603_CAP; MPN C1608X7S1A475K080AC
C53, C56, C57: 10uF; 0603_CAP; MPN CM105X5R106M25AT; DIGIKEY 1253-CM105X5R106M25ATCT-ND
J3: PINHD-1X2; 1X02
J4: MOLEX-PICO-SPOX-3SIDE; MOLEX-PICO-SPOX-3_SIDE
J5, J6: PINHD-1X1; 1X01
L1, L2: 10uH; NRX3015; MPN NR3015T100M
L4: WURTH_COIL_760308103204
Q1: CSD75207W15; DSBGA
R6, R7: 97.6; 0402_RES; MPN RMCF0402FT97R6; DIGIKEY RMCF0402FT97R6CT-ND
R8, R9: 162; 0402_RES; MPN RMCF0402FT162R; DIGIKEY RMCF0402FT162RCT-ND
R13, R15: 2.2k; 0402_RES; MPN RC0402FR-072K2L
R18, R23: 10k; 0402_RES; MPN RC0402JR-0710KL; DIGIKEY 311-10KJRCT-ND
R26: 261k; 0201_RES; MPN ERJ-1GNF2613C
R27: 402k; 0201_RES; MPN ERJ-1GNF4023C
R28, R29: 845k; 0201_RES; MPN ERJ-1GNF8453C
R30: 1.87M; 0402_RES; TOLERANCE 1%; MPN RMCF0402FT1M87
R31: 5.1M; 0402_RES; TOLERANCE 1%; MPN RMCF0402FT5M10; DIGIKEY RMCF0402FT5M10CT-ND
R33, R34: 5.1M; 0402_RES; MPN RMCF0402FT5M10; DIGIKEY RMCF0402FT5M10CT-ND
RT1: 10k@25C; 0402_RES; MPN NCU15XH103F60RC; DIGIKEY 490-18149-1-ND
RX7, RX14: DNP; 0402_RES
S1: 450404015514; DIGIKEY 732-13665-1-ND
SJ2: JUMPER-SMT_3_1-NC_TRACE_SILK; SMT-JUMPER_3_1-NC_TRACE_SILK
U3: BQ24040; DSQ0010A
U4: BQ51013B; RHL0020A
VR1: RT8020RT8020GQW; SON45P300X300X80-13T160X250N
XJ1: USB4110-GF-A; GCT_USB4110-GF-A
XR16, XR17: 5.1k; 0402_RES; MPN RMCF0402FT5K10; DIGIKEY RMCF0402FT5K10CT-ND
XR19: 10k; 0402_RES; MPN RC0402JR-0710KL; DIGIKEY 311-10KJRCT-ND

Connections:
!AD_EN: Q1.A1 (G1), Q1.C1 (G2), U4.8 (!AD-EN)
+2V5: C7.P$1 (1), C47.2, J5.1, L1.P$2 (2), R28.2; also elsewhere on the board
AP4_GP18/TT_BATIN: C27.1, R30.2, R31.1; also elsewhere on the board
AP4_GP58/TT_!CHG: U3.8 (!CHG), U4.7 (!CHG); also elsewhere on the board
AP4_GP60/TT_!PG: U3.5 (!PG); also elsewhere on the board
AP4_GP66/TT_QI_TS_CTRL: C30.1, RT1.2, U4.13 (TS/CTRL); also elsewhere on the board
BATT_THERM: J4.2, J4.2SUPP (2), SJ2.3; also elsewhere on the board
BATT_TS: SJ2.2, U3.9 (TS); also elsewhere on the board
BQ_AC1: C9.1, C10.1, C15.2, C17.1, C18.1, C19.1, C20.2, C38.2, U4.2 (AC1)
BQ_AC2: C9.2, C10.2, C16.2, C21.2, C39.2, L4.P$2 (2), U4.19 (AC2)
BQ_BOOT1: C15.1, U4.3 (BOOT1)
BQ_BOOT2: C16.1, U4.17 (BOOT2)
BQ_CLAMP1: C38.1, U4.5 (CLAMP1)
BQ_CLAMP2: C39.1, U4.16 (CLAMP2)
BQ_COMM1: C20.1, U4.6 (COMM1)
BQ_COMM2: C21.1, U4.15 (COMM2)
BQ_FOD: R7.1, R9.2, R23.2, U4.14 (FOD)
BQ_ILM: R8.1, U4.12 (ILIM)
BQ_ISET: R15.2, U3.2 (ISET)
BQ_RECT: C28.1, C56.1, C57.1, R18.1, U4.18 (RECT)
COIL_AC1: C17.2, C18.2, C19.2, L4.P$1 (1)
D+: XJ1.A6 (DP1), XJ1.B6 (DP2)
D-: XJ1.A7 (DN1), XJ1.B7 (DN2)
GND: C27.2, C28.2, C29.2, C30.2, C40.1, C41.2, C42.2, C45.1, C46.2, C47.1, C48.2, C53.2, C56.2, C57.2, J3.2 (SWDIO), J4.1, J4.1SUPP (1), R6.2, R15.1, R26.1, R27.1, R30.1, RX7.1, RX14.1, U3.3 (VSS), U3.7 (ISET2), U3.PAD (VSS), U4.1 (PGND), U4.10 (EN1), U4.11 (EN2), U4.20 (PGND), U4.PAD (PGND), VR1.3 (GND2), VR1.9 (GND1), VR1.13 (GND2), XJ1.A1/B12 (GND), XJ1.B1/A12 (GND), XJ1.S1 (GND), XJ1.S2 (GND), XJ1.S3 (GND), XJ1.S4 (GND), XR16.2, XR17.2, XR19.1; also elsewhere on the board
unnamed: R6.1, R7.2
unnamed 122: SJ2.1, XR19.2; also elsewhere on the board
unnamed: RX7.2, U3.4 (PRETERM)
unnamed: R18.2, R23.1
unnamed: R8.2, R9.1
unnamed: R13.2, RT1.1
unnamed 127: R13.1, RX14.2; also elsewhere on the board
VBAT: C42.1, J3.1 (VTREF), J4.3, J4.3SUPP (3), S1.2, U3.10 (OUT); also elsewhere on the board
VBAT_SWITCHED: C45.2, C48.1, R31.2, R33.1, R34.1, S1.3, VR1.1 (VIN2), VR1.7 (VIN1)
VQI: C29.1, C41.1, C53.1, Q1.A2 (D1), Q1.A3 (D1), Q1.B3 (D1), U3.1 (IN), U4.4 (OUT)
VR1_1P8_EN: R34.2, VR1.6 (EN1)
VR1_2P5_EN: R33.2, VR1.12 (EN2)
VR1_FB1: C8.P$1 (1), R27.2, R29.2, VR1.4 (FB1)
VR1_FB2: C7.P$2 (2), R26.2, R28.1, VR1.10 (FB2)
VR1_LX1: L2.P$2 (2), VR1.8 (LX1)
VR1_LX2: L1.P$1 (1), VR1.2 (LX2)
VUSB: C40.2, Q1.B2 (D2), Q1.C2 (D2), Q1.C3 (D2), U4.9 (AD), XJ1.A4/B9 (VBUS), XJ1.B4/A9 (VBUS)

Notes on the sheet:
2.5V Rail DW.VDD2 88 mA (100) LNA 10.6 mA 9DOF 12.3 mA (15) Buzzer 90 mA (150) ------------------------ 200.9 mA (265) 40%I->L: 6.5 uH ( 9.2) ∆IL 85 mA (120) COUT=4.7uF, ESR@1.5MHz=0.005 ∆Vout 1.9 mV ( 2.7) ** After ^math, moved the VDDAUDA LDO from battery to hang off 2.5V for routing [plus some e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
1.8V Rail DW.VDD1 10 mA (10) DW.VDD3 70 mA (100) Flash 35 mA (50) 9DOF 12.3 mA (15) Apollo4 11.3 mA (120) ------------------------ 141.6 (295) 40%I->L: 5.8 uH ( 11.3) ∆IL 68 mA (132) COUT=4.7uF, ESR@1.5MHz=0.005 ∆Vout 1.5 mV ( 3)
Vout = Vref * (1 + R1/R2) Vref=0.6V, R1=850kΩ R2 = 850e3/((2.5/.6)-1) = 268.4kΩ R2 = 850e3/((1.875/.6)-1) = 400.0kΩ Note: 1.8 -> 1.875 to balance buffer above 1.8~1.85 for AP4 and below the hard max of 1.95 for the flash chip
Switch Current Rating: 250 mA (Assume 90% eff) 2.5: (150*2.5)/(3.4*.9) = 125 1.8: (200*1.8)/(3.4*.9) = 120
Actual: 402k -> 1.8687V
Actual: 261k -> 2.554V

Notices in the files:
parts and their libraries:
Wurth_Switch_WS-SLSU: Copyright: Würth Elektronik
SparkFun-Jumpers: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
